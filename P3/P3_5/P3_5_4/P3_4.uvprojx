# Keil uVision project P3_4.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P3_4
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c lpc17xx_uart.h lpc17xx_uart.c lpc17xx_pinsel.h lpc17xx_pinsel.c lpc17xx_libcfg.h lpc17xx_iap.h lpc17xx_clkpwr.h lpc17xx_clkpwr.c lpc_types.h debug_frmwrk.h debug_frmwrk.c lpc17xx_libcfg_default.c lpc17xx_libcfg_default.h lpc17xx_iap.c
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
